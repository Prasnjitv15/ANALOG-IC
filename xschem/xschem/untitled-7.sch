v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
L 4 230 50 230 300 {}
L 4 230 50 600 160 {}
L 4 230 300 600 160 {}
